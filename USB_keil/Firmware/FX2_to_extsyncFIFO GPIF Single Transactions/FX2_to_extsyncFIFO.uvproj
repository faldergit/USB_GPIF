# Keil uVision project FX2_to_extsyncFIFO.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: FX2_to_extsyncFIFO +hex
  c flags: Optimize=6 SizeSpeed=1
  c include: C:\Users\admin\Downloads\AN66806\FX2LP Source code and GPIF project files\Firmware\FX2_to_extsyncFIFO GPIF Single Transactions\;C:\Users\admin\Downloads\AN66806\FX2LP Source code and GPIF project files\Firmware\GPIF Clock Divider\
  group Source Group 1
    ./: fw.c dscr.a51 FX2_to_extsyncFIFO.c gpif.c EZUSB.LIB USBJmpTb.OBJ
